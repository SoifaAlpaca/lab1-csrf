options:
  parameters:
    generate_options: qt_gui
    id: Lab0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandpass_bandwidth
  id: variable_qtgui_range
  parameters:
    label: Signal frequency
    start: '1'
    step: '1000'
    stop: '100000'
    value: '90000'
  states: {}
- name: emitter_cutoff_LP
  id: variable_qtgui_range
  parameters:
    label: Emitter cutoff freq
    start: '100'
    step: '10'
    stop: '45000'
    value: '40000'
  states: {}
- name: emitter_power_amplifier_a1
  id: variable_qtgui_range
  parameters:
    label: Emitter amplifier a1
    start: '0'
    step: '0.5'
    stop: '20'
    value: '1'
  states: {}
- name: emitter_power_amplifier_a2
  id: variable_qtgui_range
  parameters:
    label: Emitter amplier a2
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: emitter_power_amplifier_a3
  id: variable_qtgui_range
  parameters:
    label: Emitter amplifier a3
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: emitter_transition_LP
  id: variable_qtgui_range
  parameters:
    label: Emitter transition freq
    start: '0'
    step: '10'
    stop: '1000'
    value: '500'
  states: {}
- name: modulation_frequency
  id: variable_qtgui_range
  parameters:
    label: modulation frequency
    start: '10000'
    step: '10000'
    stop: '200000'
    value: '100000'
  states: {}
- name: receiver_power_amplifier_a1
  id: variable_qtgui_range
  parameters:
    label: a1
    start: '0'
    step: '0.5'
    stop: '20'
    value: '1'
  states: {}
- name: receiver_power_amplifier_a2
  id: variable_qtgui_range
  parameters:
    label: a2
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: receiver_power_amplifier_a3
  id: variable_qtgui_range
  parameters:
    label: a3
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_channel_atenuation
  id: variable_qtgui_range
  parameters:
    label: atenuation
    start: '1'
    step: '1'
    stop: '100'
    value: '4'
  states: {}
- name: variable_m
  id: variable_qtgui_range
  parameters:
    label: modulation index
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: variable_x_freq
  id: variable_qtgui_range
  parameters:
    label: Signal frequency
    start: '0'
    step: '1'
    stop: '5000'
    value: '500'
  states: {}
- name: variable_y_freq
  id: variable_qtgui_range
  parameters:
    label: Signal frequency
    start: '0'
    step: '1'
    stop: '5000'
    value: '250'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.2'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_x_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_y_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: modulation_frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: modulation_frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: modulation_frequency + 20000
    low_cutoff_freq: modulation_frequency - 20000
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '40000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileOutput/Q_16_qam.data
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileOutput/I_16_qam.data
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileOutput/I_qpsk.data
    type: float
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileOutput/Q_qpsk.data
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileInput/I_16_qam.data
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileInput/Q_16_qam.data
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileInput/Q_qpsk.data
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileInput/I_qpsk.data
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: receiver_power_amplifier_a1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: emitter_power_amplifier_a1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: receiver_power_amplifier_a2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/variable_channel_atenuation
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: emitter_power_amplifier_a3
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: receiver_power_amplifier_a3
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: emitter_power_amplifier_a3
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_m
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_m
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: emitter_cutoff_LP
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: emitter_transition_LP
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: emitter_cutoff_LP
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: emitter_transition_LP
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: emitter_cutoff_LP
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: emitter_transition_LP
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: emitter_cutoff_LP
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: emitter_transition_LP
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: original_I_signal
    label2: processed_I_signal
    label3: processed_Q_signal
    label4: original_Q_signal
    nconnections: '4'
    type: float
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Emitter_output
    type: float
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: original_I_signal
    label2: processed_I_signal
    label3: processed_Q_signal
    label4: original_Q_signal
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: emitter_output
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: original_I_signal
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: original_Q_signal
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: processed_Q_signal
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: processed_I_signal
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: emitter_output
  states: {}
- name: virtual_sink_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_output
  states: {}
- name: virtual_sink_0_2_1_0_0
  id: virtual_sink
  parameters:
    stream_id: I_modulation
  states: {}
- name: virtual_sink_0_2_1_0_1
  id: virtual_sink
  parameters:
    stream_id: Q_modulation
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_output
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: I_modulation
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Q_modulation
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Q_modulation
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: I_modulation
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: emitter_output
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: emitter_output
  states: {}
- name: virtual_source_0_2_1
  id: virtual_source
  parameters:
    stream_id: original_I_signal
  states: {}
- name: virtual_source_0_2_2
  id: virtual_source
  parameters:
    stream_id: original_Q_signal
  states: {}
- name: virtual_source_0_2_3
  id: virtual_source
  parameters:
    stream_id: processed_I_signal
  states: {}
- name: virtual_source_0_2_4
  id: virtual_source
  parameters:
    stream_id: processed_Q_signal
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', low_pass_filter_1, '0']
- [analog_sig_source_x_0_0, '0', low_pass_filter_1_0, '0']
- [analog_sig_source_x_0_0_0, '0', virtual_sink_0_2_1_0_0, '0']
- [analog_sig_source_x_0_0_1, '0', virtual_sink_0_2_1_0_1, '0']
- [band_pass_filter_0, '0', blocks_throttle_0_0, '0']
- [band_pass_filter_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_add_xx_1_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_1_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_add_xx_1_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_add_xx_3, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_3, '0', blocks_multiply_xx_0_3_0_0, '0']
- [blocks_add_xx_3, '0', blocks_multiply_xx_0_3_0_0, '1']
- [blocks_add_xx_3, '0', blocks_multiply_xx_0_3_0_0, '2']
- [blocks_add_xx_3, '0', blocks_multiply_xx_0_3_1, '0']
- [blocks_add_xx_3, '0', blocks_multiply_xx_0_3_1, '1']
- [blocks_file_source_0, '0', low_pass_filter_1, '0']
- [blocks_file_source_0_0, '0', low_pass_filter_1_0, '0']
- [blocks_file_source_0_0_0, '0', low_pass_filter_1_0, '0']
- [blocks_file_source_0_1, '0', low_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_1_0, '0', virtual_sink_0_1_0_0_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', blocks_add_xx_1_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1, '2']
- [blocks_multiply_const_vxx_2_0, '0', blocks_add_xx_1_0, '2']
- [blocks_multiply_const_vxx_3, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_3, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_3_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_const_vxx_3_0, '0', virtual_sink_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_3, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_3, '1']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_3, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_xx_0_3_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_xx_0_3_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_multiply_xx_0_3_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_null_source_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0_0, '0', virtual_sink_0_1_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0_1, '0']
- [low_pass_filter_0_0, '0', virtual_sink_0_1_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_3, '0']
- [low_pass_filter_1_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_3, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_3, '1']
- [virtual_source_0, '0', blocks_multiply_xx_0_3_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_3_0, '1']
- [virtual_source_0, '0', blocks_multiply_xx_0_3_0, '2']
- [virtual_source_0_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [virtual_source_0_0_1, '0', blocks_multiply_xx_0_1, '0']
- [virtual_source_0_1, '0', blocks_add_xx_0, '0']
- [virtual_source_0_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_2_1, '0', blocks_null_sink_0, '0']
- [virtual_source_0_2_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_2_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_2_2, '0', blocks_null_sink_0, '1']
- [virtual_source_0_2_2, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_0_2_2, '0', qtgui_time_sink_x_0, '3']
- [virtual_source_0_2_3, '0', blocks_file_sink_0_0, '0']
- [virtual_source_0_2_3, '0', blocks_file_sink_0_0_0, '0']
- [virtual_source_0_2_3, '0', blocks_null_sink_0, '2']
- [virtual_source_0_2_3, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_2_3, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_2_4, '0', blocks_file_sink_0, '0']
- [virtual_source_0_2_4, '0', blocks_file_sink_0_1, '0']
- [virtual_source_0_2_4, '0', blocks_null_sink_0, '3']
- [virtual_source_0_2_4, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_0_2_4, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
