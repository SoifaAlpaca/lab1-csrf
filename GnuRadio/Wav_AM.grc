options:
  parameters:
    generate_options: qt_gui
    id: Wav_AM
    output_language: python
    title: WAV to AM to Audio
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_Base_Band
  id: variable_qtgui_range
  parameters:
    label: Base Band, Band
    start: '1000'
    step: '1'
    stop: '100000'
    value: '40000'
  states: {}
- name: variable_a1
  id: variable_qtgui_range
  parameters:
    label: a1
    start: '0'
    step: '0.5'
    stop: '20'
    value: '7'
  states: {}
- name: variable_a2
  id: variable_qtgui_range
  parameters:
    label: a2
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: variable_a3
  id: variable_qtgui_range
  parameters:
    label: a3
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: variable_channel_atenuation
  id: variable_qtgui_range
  parameters:
    label: atenuation
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: variable_fc
  id: variable_qtgui_range
  parameters:
    label: central frequency
    start: '0'
    step: '1'
    stop: '100000'
    value: '100000'
  states: {}
- name: variable_m
  id: variable_qtgui_range
  parameters:
    label: modulation index
    start: '0'
    step: '1'
    stop: '1000'
    value: '1'
  states: {}
- name: variable_x_freq
  id: variable_qtgui_range
  parameters:
    label: Signal frequency
    start: '0'
    step: '1'
    stop: '5000'
    value: '500'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_x_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_channel_atenuation
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a3
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_m
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/martim/Downloads/output.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '30000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '500'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '30000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '500'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
    wintype: window.WIN_FLATTOP
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_output
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: original_signal
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: processed_signal
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: channel_input
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: LNA_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_output
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: original_signal
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: processed_signal
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: channel_input
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: LNA_out
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', low_pass_filter_0_0, '0']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_1_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1, '2']
- [blocks_multiply_const_vxx_3, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_3, '0', virtual_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0_2, '0']
- [blocks_multiply_xx_0_3, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_xx_0_3_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0_1, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_3, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '1']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_3, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_3, '1']
- [virtual_source_0, '0', blocks_multiply_xx_0_3_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_3_0, '1']
- [virtual_source_0, '0', blocks_multiply_xx_0_3_0, '2']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0_0, '0', audio_sink_0, '0']
- [virtual_source_0_0_0, '0', blocks_null_sink_0, '0']
- [virtual_source_0_0_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_1, '0', blocks_add_xx_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
