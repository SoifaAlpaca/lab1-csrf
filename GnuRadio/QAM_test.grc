options:
  parameters:
    generate_options: qt_gui
    id: QAM_test
    output_language: python
    title: QAM tests
  states: {}

blocks:
- name: Base_Band
  id: variable_qtgui_range
  parameters:
    label: Base Band Frequency
    start: '0'
    step: '1'
    stop: '50000'
    value: '40000'
  states: {}
- name: Sig_band
  id: variable_qtgui_range
  parameters:
    label: Sig_band
    start: '0'
    step: '1'
    stop: '100000'
    value: '40000'
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_a1
  id: variable_qtgui_range
  parameters:
    label: a1
    start: '0'
    step: '0.5'
    stop: '20'
    value: '7'
  states: {}
- name: variable_a2
  id: variable_qtgui_range
  parameters:
    label: a2
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: variable_a3
  id: variable_qtgui_range
  parameters:
    label: a3
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: variable_channel_atenuation
  id: variable_qtgui_range
  parameters:
    label: atenuation
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: variable_fc
  id: variable_qtgui_range
  parameters:
    label: central frequency
    start: '0'
    step: '1'
    stop: '100000'
    value: '100000'
  states: {}
- name: variable_m
  id: variable_qtgui_range
  parameters:
    label: modulation index
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: variable_x_freq
  id: variable_qtgui_range
  parameters:
    label: Signal frequency
    start: '0'
    step: '1'
    stop: '5000'
    value: '500'
  states: {}
- name: variable_y_freq
  id: variable_qtgui_range
  parameters:
    label: Signal frequency
    start: '0'
    step: '1'
    stop: '5000'
    value: '250'
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_x_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_y_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 'variable_fc + (Sig_band/2) '
    low_cutoff_freq: 'variable_fc - (Sig_band/2) '
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: filter_transition
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileOutput/I_16_qam.data
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileOutput/Q_16_qam.data
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileOutput/I_symb_in.data
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileOutput/Q_symb_in.data
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileInput/I_16_qam.data
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /Users/martim/Uni/MEEC/SM3/CSRF/Lab/lab1-csrf/GnuRadio/FileInput/Q_16_qam.data
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_channel_atenuation
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_a3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_m
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_m
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_3_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_3_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_3_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: channels_phase_noise_gen_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: '0'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: Base_Band
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: Base_Band
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: Sig_band
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: filter_transition
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: Sig_band
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: filter_transition
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: Sig_band
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: filter_transition
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: original_cosine_signal
    label2: original_sine_signal
    nconnections: '2'
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_output
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: original_cosine_signal
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: original_sine_signal
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: processed_sine_signal
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: processed_cosine_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: PA_input
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: channel_input
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: LNA_output
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_output
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: channel_input
  states: {}
- name: virtual_source_0_2_1
  id: virtual_source
  parameters:
    stream_id: original_cosine_signal
  states: {}
- name: virtual_source_0_2_2
  id: virtual_source
  parameters:
    stream_id: original_sine_signal
  states: {}
- name: virtual_source_0_2_3
  id: virtual_source
  parameters:
    stream_id: processed_cosine_signal
  states: {}
- name: virtual_source_0_2_4
  id: virtual_source
  parameters:
    stream_id: processed_sine_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: PA_input
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: LNA_output
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', low_pass_filter_1_0, '0']
- [analog_sig_source_x_0_0, '0', low_pass_filter_1_0_0, '0']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_0_1, '1']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_3, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_3, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_3_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_3_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_3_0, '2']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_3, '0']
- [blocks_add_xx_1_0, '0', virtual_sink_2, '0']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_complex_to_float_1, '1', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_file_source_0, '0', low_pass_filter_1_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_file_source_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_file_source_0_0, '0', low_pass_filter_1_0_1, '0']
- [blocks_file_source_0_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', blocks_add_xx_1_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1, '2']
- [blocks_multiply_const_vxx_2_0, '0', blocks_add_xx_1_0, '2']
- [blocks_multiply_const_vxx_3, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_3, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_3_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_3_0, '0', virtual_sink_0_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_xx_0_0, '0', virtual_sink_1, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_3, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_xx_0_3_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_xx_0_3_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_multiply_xx_0_3_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [low_pass_filter_0, '0', virtual_sink_0_1, '0']
- [low_pass_filter_0_0, '0', virtual_sink_0_1_0, '0']
- [low_pass_filter_1_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_1_0, '0', blocks_multiply_const_vxx_3, '0']
- [low_pass_filter_1_0, '0', qtgui_freq_sink_x_2, '1']
- [low_pass_filter_1_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_1_0_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [low_pass_filter_1_0_1, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_1_0_1, '0', qtgui_time_sink_x_1, '3']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [virtual_source_0_2_1, '0', blocks_null_sink_0, '0']
- [virtual_source_0_2_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_2_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_2_2, '0', blocks_null_sink_0, '1']
- [virtual_source_0_2_3, '0', blocks_null_sink_0, '2']
- [virtual_source_0_2_3, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_2_3, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_2_4, '0', blocks_null_sink_0, '3']
- [virtual_source_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_3_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_3_0_0, '1']
- [virtual_source_1, '0', blocks_multiply_xx_0_3_0_0, '2']
- [virtual_source_1, '0', blocks_multiply_xx_0_3_1, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_3_1, '1']
- [virtual_source_2, '0', blocks_complex_to_float_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
